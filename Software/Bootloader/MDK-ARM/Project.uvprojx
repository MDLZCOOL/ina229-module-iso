# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: CS32L010 Chipsea
  pack: Chipsea.CS32L010_DFP.1.0.5
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER
  c misc: --gnu
  c include: ../Libraries/CS32L010_HAL_Driver/Inc;../Libraries/CMSIS/Device/CHIPSEA/CS32L010/Include;..\User\APP\Inc;..\User\BSP\Inc;..\User\SEGGER\RTT;..\User\BSP;..\User\ymodem
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xffc
  group APP
    ../User/APP/Src/: main.c
  group BSP
    ../User/BSP/: cs32l010_hal_msp.c cs32l010_it.c
    ../User/BSP/Src/: bsp_led.c bsp_uart_fifo.c bsp_cpu_flash.c
  group SEGGER
    ../User/SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group ymodem
    ../User/ymodem/: ymodem.c
software components: CMSIS:CORE 5.6.0, Device:HAL:ADC 1.0.0, Device:HAL:AWK 1.0.0, Device:HAL:BASTIM 1.0.0, Device:HAL:BEEP 1.0.0, Device:HAL:CLKTRIM 1.0.0, Device:HAL:CORTEX 1.0.0, Device:HAL:CRC 1.0.0, Device:HAL:FLASH 1.0.0, Device:HAL:Framework 1.0.0, Device:HAL:GPIO 1.0.0, Device:HAL:I2C 1.0.0, Device:HAL:IWDG 1.0.0, Device:HAL:LPTIM 1.0.0, Device:HAL:LPUART 1.0.0, Device:HAL:LVD 1.0.0, Device:HAL:OWIRE 1.0.0, Device:HAL:PCA 1.0.0, Device:HAL:PWR 1.0.0, Device:HAL:RCC 1.0.0, Device:HAL:RTC 1.0.0, Device:HAL:SPI 1.0.0, Device:HAL:TIM 1.0.0, Device:HAL:UART 1.0.0, Device:HAL:VC 1.0.0, Device:HAL:WWDG 1.0.0, Device:Startup 1.0.0
